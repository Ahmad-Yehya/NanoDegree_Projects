# Keil uVision project project1_blink_LED.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project1_blink_LED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./: main.c
  group MCAL
    ./: port.c port.h NVIC.c NVIC.h systick.c systick.h
  group common
    ./: tiva_c_it.c tiva_c_registers.h common_macros.h tiva_c_it.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
